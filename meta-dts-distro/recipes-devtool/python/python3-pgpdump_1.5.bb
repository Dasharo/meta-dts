SUMMARY = "PGP packet parser library"
HOMEPAGE = "https://pypi.org/project/pgpdump/"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://COPYRIGHT;md5=d8b3cb8278a76dc8de839fecf2e15e64"

SRC_URI[sha256sum] = "1c4700857bf7ba735b08cfe4101aa3a4f5fd839657af249c17b2697c20829668"

inherit pypi setuptools3
