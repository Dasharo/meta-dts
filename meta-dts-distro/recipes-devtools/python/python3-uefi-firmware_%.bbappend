# nooelint: oelint.append.protvars
PV = "1.13"
# nooelint: oelint.append.protvars
SRCREV = "6d7cf5f0672c577028462ec175fec9fda95cc5f0"
