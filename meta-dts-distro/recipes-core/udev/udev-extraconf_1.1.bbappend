FILESEXTRAPATHS:append := "${THISDIR}/files"

SRC_URI:append = " \
    file://0001-add-device-symlinks-udev.patch \
"
