insane_skip += "buildpaths"
