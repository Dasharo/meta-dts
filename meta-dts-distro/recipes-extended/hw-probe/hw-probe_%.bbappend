INSANE_SKIP:${PN} += "already-stripped"
